## src/drivers/imu/bosch/bmi270_i2c/Kconfig
```kconfig
menuconfig DRIVERS_IMU_BOSCH_BMI270_I2C
	bool "bosch bmi270_i2c"
	default n
	---help---
		Enable support for bosch bmi270
```
